# Keil uVision project LCD1602.uvproj, settings and files
target LCD1602 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: LCD1602 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE
  group USER
    ./: LCD1602_main.c
  group HARDWARE
    ../HARDWARE/: lcd1602.c
