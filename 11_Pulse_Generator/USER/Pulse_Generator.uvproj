# Keil uVision project Pulse_Generator.uvproj, settings and files
target Pulse_Generator (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Pulse_Generator +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE
  group USER
    ./: Pulse_Generator_main.c
  group HARDWARE
    ../HARDWARE/: lcd1602.c
