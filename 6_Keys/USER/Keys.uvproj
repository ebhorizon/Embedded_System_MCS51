# Keil uVision project Keys.uvproj, settings and files
target SeparateKeys_Advanced (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Keys +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE
  group USER
    ./: SeparateKeys_Advanced_main.c SeparateKeys_Classic_main.c SeparateKeys_ElectronicWatch_main.c MatrixKeys_Advanced_main.c MatrixKeys_Classic_main.c
  group HARDWARE
    ../HARDWARE/: key.c key_classic.c matrix_key.c 74xx138.c matrix_key_classic.c
target SeparateKeys_Classic (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Keys +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE
target SeparateKeys_ElectronicWatch (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Keys +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE
target MatrixKeys_Advanced (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Keys +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE
target MatrixKeys_Classic (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Keys +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE
