# Keil uVision project Relay.uvproj, settings and files
target Relay (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Relay +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE
  group USER
    ./: Relay_main.c
  group HARDWARE
    ../HARDWARE/: relay.c
