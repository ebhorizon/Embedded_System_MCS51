# Keil uVision project External_Interrupt.uvproj, settings and files
target External_Interrupt0_LowLevelTrigger (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: External_Interrupt +hex
  c flags: Optimize=8 SizeSpeed=1
  group USER
    ./: External_Interrupt0_LowLevelTrigger_main.c External_Interrupt1_FallingEdgeTrigger_main.c
target External_Interrupt1_FallingEdgeTrigger (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: External_Interrupt +hex
  c flags: Optimize=8 SizeSpeed=1
