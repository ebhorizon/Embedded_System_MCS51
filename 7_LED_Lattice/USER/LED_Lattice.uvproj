# Keil uVision project LED_Lattice.uvproj, settings and files
target LED_Lattice (MCS-51)
  device: 80C51BH Intel
  cpu: IRAM(0-0x7F)  IROM(0-0xFFF) CLOCK(12000000)
  output: LED_Lattice +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE
  group USER
    ./: LED_Lattice_main.c
  group HARDWARE
    ../HARDWARE/: 74xx595.c
