# Keil uVision project LED_Segment_Displays.uvproj, settings and files
target LED_1_Segment_Display (MCS-51)
  device: 80C51BH Intel
  cpu: IRAM(0-0x7F)  IROM(0-0xFFF) CLOCK(12000000)
  output: LED_Segment_Displays +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE
  group USER
    ./: 1seg_main.c 1seg_74xx164_main.c 8seg_main.c 8seg_CC_74xx138_main.c
  group HARDWARE
    ../HARDWARE/: 1seg.c 74xx164.c 1seg_74xx164.c 8seg.c 74xx138.c 8seg_CC_74xx138.c
target LED_1_Segment_Display_74xx164 (MCS-51)
  device: 80C51BH Intel
  cpu: IRAM(0-0x7F)  IROM(0-0xFFF) CLOCK(12000000)
  output: LED_Segment_Displays +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE
target LED_8_Segment_Displays (MCS-51)
  device: 80C51BH Intel
  cpu: IRAM(0-0x7F)  IROM(0-0xFFF) CLOCK(12000000)
  output: LED_Segment_Displays +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE
target LED_8_Segment_Displays_74xx138 (MCS-51)
  device: 80C51BH Intel
  cpu: IRAM(0-0x7F)  IROM(0-0xFFF) CLOCK(12000000)
  output: LED_Segment_Displays +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE
