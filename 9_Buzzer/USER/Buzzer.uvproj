# Keil uVision project Buzzer.uvproj, settings and files
target Buzzer (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Buzzer +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE
  group USER
    ./: Buzzer_main.c
  group HARDWARE
    ../HARDWARE/: buzzer.c
