# Keil uVision project Timer_Counter.uvproj, settings and files
target Timer_Counter_SquareWave (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Timer_Counter +hex
  c flags: Optimize=8 SizeSpeed=1
  group USER
    ./: Timer_Counter_SquareWave_main.c Timer_Counter_ElectronicWatch_main.c
  group HARDWARE
    ../HARDWARE/: 74xx138.c
target Timer_Counter_ElectronicWatch (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Timer_Counter +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE
