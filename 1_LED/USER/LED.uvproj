# Keil uVision project LED.uvproj, settings and files
target LED (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LED +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/: led.c
