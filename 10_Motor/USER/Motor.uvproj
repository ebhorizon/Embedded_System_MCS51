# Keil uVision project Motor.uvproj, settings and files
target DC_Motor_ULN2003 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Motor +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE
  group USER
    ./: DC_Motor_ULN2003_main.c DC_Motor_ULN2003_PWM_main.c 4_Wire_2_Phase_Bipolar_SteppingMotor_UDN2916_main.c
  group HARDWARE
    ../HARDWARE/: key.c uln2003.c udn2916.c
target DC_Motor_ULN2003_PWM (MCS-51)
  device: STC89C52RC STC
  cpu: as above
  output: Motor +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE
target 4_Wire_2_Phase_Bipolar_SteppingMotor_UDN2916 (MCS-51)
  device: STC89C52RC STC
  cpu: as above
  output: Motor +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE
